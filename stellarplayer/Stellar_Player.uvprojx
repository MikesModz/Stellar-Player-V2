# Keil uVision project Stellar_Player.uvprojx, settings and files
target LM4F120_LaunchPad (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Stellar_Player +hex
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR TARGET_IS_BLIZZARD_RA2 no_unaligned_access
  c include: C:\StellarisWare;C:\StellarisWare\inc;C:\StellarisWare\boards\ek-lm4f120xl
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Stellar_Player.sct
  link misc: --entry Reset_Handler
  group User
    ./User/: stellar_player.c mod32.c player.c s3m32.c strcasestr.c
    C:/StellarisWare/boards/ek-lm4f120xl/drivers/: buttons.c
  group Libraries
    C:/StellarisWare/driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
  group FatFS
    ./User/fatfs/: ff.c mmc-ek-lm4f232h5qd.c diskio.h ff.h ffconf.h integer.h
  group TFT
    ./User/tft/: glcdfont.h integer.h tft.c tft.h
  group ::Device
    RTE/Device/LM4F120H5QR/: Startup.s
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
